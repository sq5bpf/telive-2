options:
  parameters:
    author: Jacek Lipkowski SQ5BPF
    category: Custom
    generate_options: qt_gui
    id: telive_1ch_simple_gr310_udp_xmlrpc
    output_language: python
    title: SQ5BPF Tetra live receiver 1ch simple UDP demo with fixed offset (gnuradio 3.10 version) xmlrpc
  states: {}

blocks:
- name: first_decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: first_port
  id: variable
  parameters:
    value: '42000'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    type: real
    value: 438.0125e6
  states: {}
- name: freq_with_offset
  id: variable
  parameters:
    value: freq-xlate_offset1
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: samp_rate/first_decim
  states: {}
- name: options_low_pass
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: out_sample_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,3
    label: ppm
    start: '-100'
    step: '0.5'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sdr_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,8,1,1
    label: gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: sdr_ifgain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: telive_receiver_channels
  id: variable
  parameters:
    value: '1'
  states: {}
- name: telive_receiver_name
  id: variable
  parameters:
    value: '''SQ5BPF 1-channel rx for telive'''
  states: {}
- name: udp_dest_addr
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: udp_packet_size
  id: variable
  parameters:
    value: '1472'
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x/1000000:.4f} MHz'''
    label: 'Receive frequency: '
    type: real
    value: freq+xlate_offset_fine1
  states: {}
- name: xlate_offset1
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: xlate_offset_fine1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,3
    label: Fine tune1
    start: '-5e3'
    step: '1'
    stop: +5e3
    value: '0'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: 'note: this is a stupid hack to workaround a gnuradio bug --sq5bpf'
    msg: pmt.cons(pmt.intern("freq"),pmt.from_float(freq_with_offset))
    period: '100'
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq_with_offset
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset1+xlate_offset_fine1
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: udp_dest_addr
    header: '0'
    payloadsize: udp_packet_size
    port: first_port+1
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: ppm_corr
    freq0: freq-xlate_offset1
    gain0: sdr_gain
    gain_mode0: 'False'
    if_gain0: sdr_ifgain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,6
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: if_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: 1,6,1,6
    name: '"IF"'
    showports: 'True'
    type: complex
    update_time: '0.01'
    ymax: '-30'
    ymin: '-180'
  states: {}
- name: xlate_offset_fine1
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 3,1,1,4
    label: Fine Tune
    max: '10000'
    min: '-10000'
    num_steps: '200'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: first_port
  states: {}

connections:
- [analog_agc3_xx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_message_strobe_0, strobe, qtgui_freq_sink_x_0, freq]
- [blocks_var_to_msg_0, msgout, qtgui_freq_sink_x_0, freq]
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc3_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [mmse_resampler_xx_0, '0', network_udp_sink_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
